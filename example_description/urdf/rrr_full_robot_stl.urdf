Commit message: Sensores agregados

File: example_description/urdf/rrr_full_robot_stl.urdf (robot description, URDF)
Before this commit: robot rrr_robot, 0 links, 0 joints
Links:
- added link p_link
